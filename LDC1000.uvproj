# Keil uVision project LDC1000.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LDC1000 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\user;.\CM3;.\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ./startup/: startup_stm32f10x_hd.s
  group USR
    ./user/: main.c usart1.c delay.c stm32f10x_it.c LDC1000.c pwm.c motor.c timer.c
    ./FWlib/SRC/: misc.c
  group FWlib
    ./FWlib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c
  group CMSYS
    ./CM3/: core_cm3.c system_stm32f10x.c
  group readme
    ./user/: readme.txt
  group OLED
    ./OLED/: oled.c
